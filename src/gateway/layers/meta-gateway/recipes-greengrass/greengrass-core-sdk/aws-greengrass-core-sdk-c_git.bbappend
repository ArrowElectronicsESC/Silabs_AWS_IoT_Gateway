LIC_FILES_CHKSUM = "file://LICENSE;md5=11f57cdb0512851468f5785d100afabf"
